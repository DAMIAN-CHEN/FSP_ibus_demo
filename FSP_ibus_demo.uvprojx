# Keil uVision project FSP_ibus_demo.uvprojx, settings and files
target Target_1 (6190000::V6.19::ARMCLANG)
  device: R7FA4M2AD Renesas
  pack: Renesas.RA_DFP.5.8.0
  cpu: IRAM(0x20000000,0x020000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FSP_ibus_demo +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  c include: .\App
  asm misc: --via=via/rasc_armasm.via
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group App
    ./App/: drv_ibus.c bsp_uart_debug.c bsp_led.c
software components: Flex Software:RA Configuration 1.0.0
